# Keil uVision project STM32L151uCOS.uvprojx, settings and files
target uCOS-II (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L151uCOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\CORE;..\STM32L1xx_FWLib\inc;..\STM32L1xx_FWLib\src;..\ucOS-II\Config;..\ucOS-II\Ports;..\ucOS-II\Source;..\Common\common;..\Common\delay;..\Common\usart;..\Common\ucSTKCheck;..\User;..\Application\App;..\Application;..\Deriver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application
    ../Application/App/: app.c
    ../Application/: ledtask.c parmtask.c pwrtask.c
  group Driver
    ../Deriver/: key.c led.c rtc.c w25qxx.c
  group Common
    ../Common/common/: common.c
    ../Common/delay/: delay.c
    ../Common/usart/: usart.c
    ../Common/ucSTKCheck/: ucSTKCheck.c
  group User
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c MainConfig.h
  group Core
    ../CORE/: core_cm3.c startup_stm32l1xx_md.s
  group μcOSII_Config
    ../ucOS-II/Config/: app_hooks.c ucOSConfig.h os_cfg.h
  group μcOSII_PORT
    ../ucOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group μcOSII_CORE
    ../ucOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group FWLib
    ../STM32L1xx_FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Document
    ../: readme.md
